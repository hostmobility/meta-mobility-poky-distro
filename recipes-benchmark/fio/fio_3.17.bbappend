RDEPENDS_${PN}_remove = "python "
RDEPENDS_${PN_append = " python3"
