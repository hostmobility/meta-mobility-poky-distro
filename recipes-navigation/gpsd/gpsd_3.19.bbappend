RDEPENDS_python-pygps_remove = "python-core python-io python-threading python-terminal python-json"
RDEPENDS_python-pygps_append = " python3-core python3-io python3-threading python3-terminal python3-json"

DEPENDS_remove = "python "
