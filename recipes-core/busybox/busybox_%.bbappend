FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://hostmobility.cfg"
