CFLAG:append:class-native = " -fPIC"
PACKAGECONFIG:mxv-base += " cryptodev-linux"
